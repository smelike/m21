# Keil uVision project gd32.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, CMSIS:NN Lib 4.1.0, Device:GD32F10x_StdPeripherals:FWDGT 2.3.0, Device:GD32F10x_StdPeripherals:GPIO 2.3.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Network:CORE 7.19.0, Network:Legacy API 7.19.0, Network:Service:DNS Client 7.19.0, Network:Service:Web Server Compact 7.19.0, USB:CORE 6.17.0
